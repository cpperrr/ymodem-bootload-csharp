# Keil uVision project Project.uvprojx, settings and files
target STM3210E-XLH (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: obj
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\User\inc;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\StdPeriph_Driver\inc;..\User\FreeModbus\port;..\User\FreeModbus\modbus\tcp;..\User\FreeModbus\modbus\rtu;..\User\FreeModbus\modbus\include;..\User\FreeModbus\modbus\functions;..\User\FreeModbus\modbus\ascii
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
    ../User/src/: LED.C KEY.C
  group StdPeriph_Driver
    ../Libraries/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c startup_stm32f10x_hd.s
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
  group MODBUS
    ../User/FreeModbus/modbus/: mb.c
    ../User/FreeModbus/modbus/ascii/: mbascii.c
    ../User/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../User/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../User/FreeModbus/modbus/tcp/: mbtcp.c
  group ModbusPort
    ../User/FreeModbus/port/: portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 4.3.0
